# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 for Certification (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\Start\CMSIS\Include;.\Start\CMSIS;.\Start\CMSIS\Device\ST\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    ./Start/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group User
    ./: main.c
    ./User/: stm32f1xx_hal_msp.c stm32f1xx_it.c system.c config.h
